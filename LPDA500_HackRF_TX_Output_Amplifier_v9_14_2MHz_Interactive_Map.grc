options:
  parameters:
    author: Radio Operator
    description: Multimode HackRF transmitter with live TX monitoring and an embedded interactive online HF map tab
    generate_options: qt_gui
    id: lpda500_hackrf_tx_test
    output_language: python
    title: HackRF Multimode TX + Interactive HF Map
  states: {}

blocks:
- name: radio_tabs
  id: qtgui_tab_widget
  parameters:
    comment: Main radio visualization tabs.
    gui_hint: 0,0,1,6
    num_tabs: '2'
    label0: TX Monitor
    label1: Interactive HF Map
  states: {}
- name: sync
  id: variable
  parameters:
    comment: Keep HackRF sink synchronization enabled.
    value: 'True'
  states: {}
- name: tx_amp_linear
  id: variable
  parameters:
    comment: Linear amplitude gain corresponding to TX Output Gain in dB.
    value: 10**(tx_output_gain_db/20.0)
  states: {}
- name: audio_input_select
  id: variable_qtgui_chooser
  parameters:
    label: Audio Source
    label0: Edge + Media Player
    label1: Default Windows Input
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[''0'', ''1'']'
    type: int
    value: '0'
  states: {}
- name: carrier_freq
  id: variable_qtgui_entry
  parameters:
    label: RF Carrier Frequency (Hz) — default 14.2 MHz
    type: real
    value: 14.2e6
  states: {}
- name: ctcss_freq
  id: variable_qtgui_range
  parameters:
    label: CTCSS Frequency (0 = Off)
    start: '0'
    step: '0.1'
    stop: '254.1'
    value: '0'
  states: {}
- name: enable_tone
  id: variable_qtgui_range
  parameters:
    label: 1750 Hz Tone Burst Injection
    start: '0'
    step: '10'
    stop: '2000'
    value: '0'
  states: {}
- name: master_audio
  id: variable
  parameters:
    comment: Fixed unity TX audio level. Visual meter added separately; no volume slider.
    value: '1.0'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Spectral Floor Noise Level
    start: '0'
    step: '0.005'
    stop: '0.2'
    value: '0.0'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: ptt
  id: variable_qtgui_range
  parameters:
    label: TX ENABLE (0=OFF, 1=ON)
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_mode
  id: variable_qtgui_chooser
  parameters:
    label: Operating Mode
    label0: NBFM
    label1: AM
    label2: USB
    label3: WFM
    label4: SAT FM
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[''0'', ''1'', ''2'', ''3'', ''4'']'
    type: int
    value: '0'
  states: {}
- name: am_depth_50pct
  id: blocks_multiply_const_vxx
  parameters:
    comment: AM modulation depth limited to 50 percent.
    const: '1.0'
    type: float
  states: {}
- name: analog_ctcss_source
  id: analog_sig_source_x
  parameters:
    amp: '0.0'
    comment: CTCSS disabled at zero amplitude.
    freq: ctcss_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '1750'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: audio_input_mux
  id: blocks_selector
  parameters:
    comment: Input 0 = dedicated virtual device for Edge + Media Player. Input 1 = Windows default microphone/input.
    enabled: 'True'
    input_index: audio_input_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Captures only audio routed by Windows to the CABLE Output virtual device. Set Microsoft Edge and Windows Media Player to this output in Windows Volume Mixer.
    device_name: CABLE Output
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_am
  id: blocks_add_const_vxx
  parameters:
    comment: AM carrier bias.
    const: '1.0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_float_to_complex_am
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_usb
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-enable_tone
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: enable_tone
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: PTT gate and master TX audio level.
    const: ptt * master_audio
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: hilbert_filter_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.hilbert(63, window.WIN_HAMMING)
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: microphone_source_0
  id: audio_source
  parameters:
    comment: Blank = Windows default input device.
    samp_rate: samp_rate
  states: {}
- name: mode_selector_mux
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_mode
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: carrier_freq
    gain0: tx_gain_ui
    if_gain0: '20'
    sample_rate: out_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: out_rate
    fc: carrier_freq
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: radio_tabs@0:0,0,4,6
    type: complex
  states: {}
- name: rational_resampler_am_4x
  id: rational_resampler_xxx
  parameters:
    comment: 48 kS/s audio-derived AM path to 240 kS/s complex baseband.
    decim: '1'
    fbw: '0.4'
    interp: '5'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_usb_4x
  id: rational_resampler_xxx
  parameters:
    comment: 48 kS/s audio-derived USB path to 240 kS/s complex baseband.
    decim: '1'
    fbw: '0.4'
    interp: '5'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 240 kS/s complex baseband to 1.2 MS/s RF sample rate.
    decim: '1'
    fbw: '0.4'
    interp: '5'
    taps: ''
    type: ccc
  states: {}
- name: satellite_audio_filter
  id: low_pass_filter
  parameters:
    comment: Satellite voice audio filter; isolated from WFM.
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: satellite_nbfm_tx
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    comment: Isolated SAT FM narrowband voice path.
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: beacon_preamble_len
  id: variable_qtgui_range
  parameters:
    comment: Length of the known beacon synchronization preamble in symbols.
    label: Beacon Preamble Length (symbols)
    min_len: '260'
    rangeType: int
    start: '16'
    step: '16'
    stop: '4096'
    value: '256'
  states: {}
- name: beacon_repeat_interval
  id: variable_qtgui_range
  parameters:
    comment: Time between complete beacon repetitions in seconds.
    label: Beacon Repeat Interval (seconds)
    min_len: '260'
    start: '0.5'
    step: '0.5'
    stop: '60.0'
    value: '5.0'
  states: {}
- name: tx_gain_ui
  id: variable_qtgui_range
  parameters:
    comment: HackRF TX gain control. Do not exceed the hardware-supported range.
    label: HackRF TX Gain (dB)
    min_len: '260'
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: tx_output_gain_db
  id: variable_qtgui_range
  parameters:
    comment: Normalized digital TX amplitude before the HackRF sink.
    label: TX Output Gain (dB)
    min_len: '260'
    start: '-20.0'
    step: '0.5'
    stop: '20.0'
    value: '6.0'
  states: {}
- name: tx_amp_cmult
  id: blocks_multiply_const_vxx
  parameters:
    comment: Actual complex-IQ digital gain stage controlled by TX Output Gain.
    max_streams: '1'
    min_streams: '1'
    type: complex
    const: tx_amp_linear
  states: {}
- name: tx_rf_mag
  id: blocks_complex_to_mag
  parameters:
    comment: Magnitude for the live TX IQ level display.
  states: {}
- name: tx_audio_abs
  id: blocks_abs_xx
  parameters:
    comment: Absolute-value stage for the live TX audio level display.
    type: float
  states: {}
- name: tx_audio_level_display
  id: qtgui_number_sink
  parameters:
    avg: '0.01'
    comment: Live pre-modulation audio level. Relative digital amplitude, not calibrated watts or dBm.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: radio_tabs@0:4,0,1,3
    label1: TX AUDIO LEVEL
    min: '0'
    name: '"TX Audio Level"'
    type: float
    unit1: relative
  states: {}
- name: tx_rf_level_display
  id: qtgui_number_sink
  parameters:
    avg: '0.01'
    comment: Live complex-IQ level immediately before the RF sink. Relative digital amplitude only.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: radio_tabs@0:4,3,1,3
    label1: TX IQ LEVEL
    min: '0'
    name: '"TX IQ Level"'
    type: float
    unit1: relative
  states: {}
- name: interactive_hf_map
  id: qtgui_interactive_hf_map
  parameters:
    tx_lat: '-12.4634'
    tx_lon: '130.8456'
    frequency_mhz: '14.2'
    zoom: '3'
    gui_hint: radio_tabs@1:0,0,1,1
  states: {}

connections:
- [am_depth_50pct, '0', blocks_add_const_vxx_am, '0']
- [analog_ctcss_source, '0', blocks_add_xx_0, '2']
- [analog_nbfm_tx_0, '0', mode_selector_mux, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '3']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_tx_0, '0', mode_selector_mux, '3']
- [audio_input_mux, '0', high_pass_filter_0, '0']
- [audio_source_0, '0', audio_input_mux, '0']
- [blocks_add_const_vxx_am, '0', blocks_float_to_complex_am, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_am, '0', rational_resampler_am_4x, '0']
- [blocks_float_to_complex_usb, '0', rational_resampler_usb_4x, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', tx_amp_cmult, '0']
- [tx_amp_cmult, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', tx_audio_abs, '0']
- [tx_audio_abs, '0', tx_audio_level_display, '0']
- [tx_amp_cmult, '0', tx_rf_mag, '0']
- [tx_rf_mag, '0', tx_rf_level_display, '0']
- [tx_amp_cmult, '0', rational_resampler_xxx_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_am, '1']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [high_pass_filter_0, '0', satellite_audio_filter, '0']
- [hilbert_filter_0, '0', blocks_float_to_complex_usb, '1']
- [low_pass_filter_0, '0', am_depth_50pct, '0']
- [low_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_usb, '0']
- [low_pass_filter_0, '0', hilbert_filter_0, '0']
- [microphone_source_0, '0', audio_input_mux, '1']
- [mode_selector_mux, '0', blocks_multiply_const_vxx_2, '0']
- [rational_resampler_am_4x, '0', mode_selector_mux, '1']
- [rational_resampler_usb_4x, '0', mode_selector_mux, '2']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [satellite_audio_filter, '0', satellite_nbfm_tx, '0']
- [satellite_nbfm_tx, '0', mode_selector_mux, '4']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
